include flutter-gallery.inc

FLUTTER_RUNTIME = "release"
inherit flutter-app-custom