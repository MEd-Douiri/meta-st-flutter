include flutter-gallery.inc

FLUTTER_RUNTIME = "profile"
inherit flutter-app-custom