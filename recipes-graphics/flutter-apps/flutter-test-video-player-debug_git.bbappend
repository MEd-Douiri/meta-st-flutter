

FLUTTER_RUNTIME = "debug"
inherit flutter-app-custom