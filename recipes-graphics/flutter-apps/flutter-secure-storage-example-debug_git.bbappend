include flutter-secure-storage-example.inc

FLUTTER_RUNTIME = "debug"
inherit flutter-app-custom