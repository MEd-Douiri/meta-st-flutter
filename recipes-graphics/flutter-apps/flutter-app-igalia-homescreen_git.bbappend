inherit flutter-app-custom
SRCREV = "08bf271f7f1f14153a41005718a2090fa8e783f0"