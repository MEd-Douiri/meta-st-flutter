FLUTTER_RUNTIME = "profile"
inherit flutter-app-custom
SRCREV = "f781b036c830952fc84a85ffa37f2f51328fa0a4"