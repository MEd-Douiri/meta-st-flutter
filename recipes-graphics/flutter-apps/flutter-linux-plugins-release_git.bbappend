include flutter-linux-plugins.inc

FLUTTER_RUNTIME = "release"
inherit flutter-app-custom