inherit flutter-app-custom
SRCREV = "e716593352b80330e05729486eade7c2167d3c71"