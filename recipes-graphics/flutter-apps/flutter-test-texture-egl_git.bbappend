inherit flutter-app-custom
SRCREV = "da096d27ee8e5e74c18eb97f91ac03021363ef5b"