include flutter-secure-storage-example.inc

FLUTTER_RUNTIME = "profile"
inherit flutter-app-custom