inherit flutter-app-custom
SRCREV = "ce7bb3916197f1ccb2b64064fa3fcdf1307223f7"