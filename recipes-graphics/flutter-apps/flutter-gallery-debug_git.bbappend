FLUTTER_RUNTIME = "debug"
inherit flutter-app-custom
SRCREV = "9eb785cb997ff56c46e933c1c591f0a6f31454f6"
