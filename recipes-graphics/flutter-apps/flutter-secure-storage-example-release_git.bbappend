include flutter-secure-storage-example.inc

FLUTTER_RUNTIME = "release"
inherit flutter-app-custom