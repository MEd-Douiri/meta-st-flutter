inherit flutter-app-custom
