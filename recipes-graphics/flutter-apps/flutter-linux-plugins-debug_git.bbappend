include flutter-linux-plugins.inc

FLUTTER_RUNTIME = "debug"
inherit flutter-app-custom